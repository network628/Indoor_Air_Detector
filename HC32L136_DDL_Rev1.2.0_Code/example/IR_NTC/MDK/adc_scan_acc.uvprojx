# Keil uVision project adc_scan_acc.uvprojx, settings and files
target adc_scan_acc_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L136K8TA HDSC
  pack: HDSC.HC32L136.1.0.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SC001_TEMP +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c include: ..\..\..\mcu\common;..\source;..\..\..\driver\inc;..\..\..\midware\GUI_Control;..\..\..\midware\LCD;..\..\..\midware\SHT2X;..\..\..\midware\PM1006;..\..\..\midware\APP_Uart;..\..\..\midware\APP_Gpio;..\..\..\midware\IR_NTC;..\..\..\midware\APP_AD;..\..\..\midware\APP_Timer
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ../../../driver/src/: interrupts_hc32l136.c
    ./: startup_hc32l136.s
    ../../../mcu/common/: system_hc32l136.c
  group source
    ../source/: main.c
    ../../../midware/APP_AD/: app_ad.c
    ../../../midware/LCD/: tft_lcd.c
    ../../../midware/GUI_Control/: GUI_Control.c app.c
    ../../../midware/SHT2X/: SHT2X.c
    ../../../midware/PM1006/: PM1006.c
    ../../../midware/APP_Uart/: app_uart.c
    ../../../midware/APP_Gpio/: app_gpio.c
    ../../../midware/IR_NTC/: IR_NTC.c
    ../../../midware/APP_Timer/: app_timer.c
  group driver
    ../../../driver/src/: adc.c bt.c gpio.c flash.c ddl.c lpm.c sysctrl.c timer3.c uart.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
